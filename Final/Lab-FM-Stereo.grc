options:
  parameters:
    generate_options: qt_gui
    id: Lab_FM_Stereo
    output_language: python
    title: FM Stereo Decoding
  states: {}

blocks:
- name: FM_station
  id: variable
  parameters:
    value: '104300000'
  states: {}
- name: ratio
  id: variable
  parameters:
    value: '125'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: ratio*1000
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: '500000'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '18000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '400'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '38500'
    low_cutoff_freq: '37500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '25'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/Excelsis/Uni/3A_1S/Documents/MEEC/3o ano/Telecom/Lab/3º Lab - Aval/IQ_104,3MHz.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/Excelsis/RIGHT_POSD_2000Hz.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: '500000'
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: nota_1
  id: note
  parameters:
    note: Descodificação do sinal mono
  states: {}
- name: nota_1_0
  id: note
  parameters:
    note: Desmodulação do sinal de entrada
  states: {}
- name: nota_1_0_0
  id: note
  parameters:
    note: Váriaveis de uso
  states: {}
- name: nota_2
  id: note
  parameters:
    note: 'Detetor coerente: DSB-SC  -> [L - R] & Regen. piloto'
  states: {}
- name: nota_2_0
  id: note
  parameters:
    note: Matrix final
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"mensagem"'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"portadora piloto"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: L + R
    label2: L - R
    name: '"L + R e L - R"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: L
    label2: R
    name: '"L e R"'
    nconnections: '2'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: ratio
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: ratio
    interp: '48'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: piloto 2f
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: L + R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: L - R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: L + R
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: L - R
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: L + R
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: piloto 2f
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: L - R
  states: {}

connections:
- [analog_fm_deemph_0, '0', low_pass_filter_2, '0']
- [analog_fm_deemph_0_0, '0', low_pass_filter_1, '0']
- [analog_wfm_rcv_0, '0', virtual_sink_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0_1_0, '0', qtgui_sink_x_1, '0']
- [band_pass_filter_0_1_0, '0', virtual_sink_0_0_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_delay_1, '0', virtual_sink_1, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0_1_0, '0']
- [blocks_multiply_xx_1, '0', analog_fm_deemph_0, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', blocks_delay_1, '0']
- [low_pass_filter_2, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_2, '1']
- [rational_resampler_xxx_1_0, '0', audio_sink_0, '1']
- [rational_resampler_xxx_1_0, '0', qtgui_time_sink_x_2, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_1, '1']
- [virtual_source_1, '0', band_pass_filter_0, '0']
- [virtual_source_1, '0', band_pass_filter_0_0, '0']
- [virtual_source_1_0, '0', analog_fm_deemph_0_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0, '0']
- [virtual_source_2, '0', blocks_sub_xx_0, '0']
- [virtual_source_3, '0', blocks_multiply_xx_1, '1']
- [virtual_source_4, '0', blocks_add_xx_0, '1']
- [virtual_source_4, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-237-gc49548c2
